# Keil uVision project BH-F103.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARM5.06)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
    ../../User/Led/: bsp_led.c
    ../../User/led/: bsp_usart.c delay.c bsp_oled.c bsp_w25q64.c pwm_timer.c bsp_timer.c bsp_Adc.c
    ./: bsp_pid.c
  group DOC
    ../../Doc/: readme.txt
  group FreeRTOS/port
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/port/MemMang/: heap_4.c
  group FreeRTOS/arc
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
